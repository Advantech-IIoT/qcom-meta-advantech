# assign emmc partition xml
PARTITION_XML = "partition_emmc.xml"
