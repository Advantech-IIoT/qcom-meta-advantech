FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-set-qcom-nativedp-orientation-1-1-to-force-native-dp.patch \
	   "

